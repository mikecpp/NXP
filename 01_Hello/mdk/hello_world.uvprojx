# Keil uVision project hello_world.uvprojx, settings and files
target hello_world debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  pack: Keil.Kinetis_SDK_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: D:/NXP_FRDM-K64F/CMSIS/Include;D:/NXP_FRDM-K64F/devices;../../..;..;D:/NXP_FRDM-K64F/devices/MK64F12/drivers;D:/NXP_FRDM-K64F/devices/MK64F12/utilities/io;D:/NXP_FRDM-K64F/devices/MK64F12/utilities/str;D:/NXP_FRDM-K64F/devices/MK64F12/utilities/log;D:/NXP_FRDM-K64F/devices/MK64F12/utilities;D:/NXP_FRDM-K64F/devices/MK64F12
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    D:/NXP_FRDM-K64F/devices/MK64F12/drivers/: fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c
  group utilities
    D:/NXP_FRDM-K64F/devices/MK64F12/utilities/io/: fsl_io.c fsl_io.h
    D:/NXP_FRDM-K64F/devices/MK64F12/utilities/log/: fsl_log.c fsl_log.h
    D:/NXP_FRDM-K64F/devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    D:/NXP_FRDM-K64F/devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    D:/NXP_FRDM-K64F/devices/MK64F12/: system_MK64F12.c system_MK64F12.h
    D:/NXP_FRDM-K64F/devices/MK64F12/arm/: startup_MK64F12.s
  group source
    ../: hello_world.c
target hello_world release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
